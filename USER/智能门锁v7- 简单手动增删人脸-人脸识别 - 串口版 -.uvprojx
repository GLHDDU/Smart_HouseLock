# Keil uVision project 智能门锁v7- 简单手动增删人脸-人脸识别 - 串口版 -.uvprojx, settings and files
target TIMER (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TIMER +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\BEEP;..\SYSTEM\TIMER;..\HARDWARE\IIC;..\HARDWARE\OLED;..\HARDWARE\AS608;..\HARDWARE\USART3;..\DoorLock;..\HARDWARE\RC522;..\HARDWARE\MENU;..\HARDWARE\MG995;..\HARDWARE\HCSR04;..\HARDWARE\RTC;..\HARDWARE\DHT11;..\NET\USART2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/IIC/: iic.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/AS608/: as608.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/RC522/: rc522.c
    ../HARDWARE/MENU/: menu.c
    ../HARDWARE/MG995/: mg995.c
    ../HARDWARE/HCSR04/: hcsr04.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/DHT11/: dht11.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/TIMER/: timer.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
  group README
    ../: README.TXT
  group DoorLock
    ../DoorLock/: doorlock.c
  group NET
    ../NET/USART2/: usart2.c
